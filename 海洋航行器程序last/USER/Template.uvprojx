# Keil uVision project Template.uvprojx, settings and files
target Template (ARM-ADS)
  device: STM32F103C8 STMicroelectronics
  cpu: IROM(0x08000000,0x10000) IRAM(0x20000000,0x5000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: Template +hex
  c flags: Optim=1
  c define: STM32F10X_MD,USE_STDPERIPH_DRIVER
  c include: ..\USER;..\SYSTEM\delay;..\SYSTEM\sys;..\SYSTEM\usart;..\ST_LIB\inc;..\MY_LIB\inc;..\CMSIS;..\MY_LIB\inc
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./: main.c stm32f10x_it.c
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group StartUp
    ../STARTUP/: startup_stm32f10x_md.s
  group MYLib
    ../MY_LIB/src/: led.c PWM_Out.c control.c watch_dog.c exti.c timer.c
  group STLib
    ../ST_LIB/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_spi.c stm32f10x_exti.c stm32f10x_iwdg.c
  group System
    ../SYSTEM/delay/: delay.c
    ../SYSTEM/sys/: sys.c
    ../SYSTEM/usart/: usart.c
software components: CMSIS:CORE 4.1.0
